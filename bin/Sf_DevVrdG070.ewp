# IAR project Sf_DevVrdG070.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G070CB ST STM32G070CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32G070xx
  ICCARM.CCIncludePath2: ..\source\pub; ..\source\app\Inc; ..\source\cpus\Inc; ..\source\products\Inc; ..\source\st25r3916\Inc; ..\source\rfal\Inc; ..\source\drivers\Inc; ..\source\interface\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Sf_DevVrdG070.hex
  ILINK.IlinkOutputFile: Sf_DevVrdG070.out
  ILINK.IlinkIcfFile: Cpu_resource_cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group app
    ../source/app/Src/: analogConfigTbl_NFC06A1.c charge_station.c demo_app.c demo_ce.c demo_polling.c logger.c main.c nfc_app.c serialProc.c
  group cpu
    ../source/cpus/Src/: gpio.c spi.c stm32g0xx_it.c stm32g0xx_iwdg.c system_stm32g0xx.c usart.c
  group driver
    ../source/drivers/Src/: Stm32G0XX_Flash.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_rcc.c stm32g0xx_ll_spi.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c Stm32g0xx_systick.c Stm32G0xxx_adc.c
  group EWARM
    ./: Cpu_resource_cfg.icf startup_stm32g0xx.s
  group interface
    ../source/interface/Src/: App_Api.c buffer.c comm_service.c common_driver.c common_media.c ctrl_service.c Knx_Run.c KnxProp_0705.c math_service.c mem_malloc.c stm32g070cbt6_st_lib_Rx_Pa9 Iar 8.40.2 V 1.04 .a
  group product
    ../source/products/Src/: Application.c Application_Data.c boardctrl.c Knx_InternalData.c Knx_Mem.c stm32g0xx_vector.c
  group rfal
    ../source/rfal/Src/: rfal_analogConfig.c rfal_crc.c rfal_dpo.c rfal_iso15693_2.c rfal_isoDep.c rfal_nfc.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_st25tb.c rfal_st25xv.c rfal_t1t.c rfal_t2t.c rfal_t4t.c
  group st25r3916
    ../source/st25r3916/Src/: rfal_rfst25r3916.c st25r3916.c st25r3916_aat.c st25r3916_com.c st25r3916_irq.c st25r3916_led.c timer.c
